#include <stdio.h>
#include <stdlib.h>
int v3[10];

 void concatena(int *a,int *b)
 {
   int i,d;

   for(i=0;i<10;i++)
   {
    if(i<5)
    {
      for(d=0;d<10;d++)
      {
      if(a[i]!=v3[d])
        v3[i]=a[i];
      }
    }
    else
        for(d=0;d<10;d++)
      {
      if(b[i-5]!=v3[d])
        v3[i]=b[i-5];
      }

   }


 }
//----------------------------------------------------------------------------------------------------
 int pertence (int *a)
  {
    if(a[i]!=v3[d])
        v3[i]=a[i];
  }
//-------------------------------------------------------------------------------------------
int main()
{
 int v1[5],v2[5],i;

   printf("digite v1,n1\n");
   for(i=0;i<5;i++)
   {
    scanf("%d",&v1[i]);
   }
   printf("digite v2,n2\n");
   for(i=0;i<5;i++)
   {
    scanf("%d",&v2[i]);
   }
    concatena(v1,v2);

   printf("\nv3 :\n");
   for(i=0;i<10;i++)
     printf("%d ",v3[i]);

 return 0;
}
//----------------------------------------------------------------------------------------------------------------------------------